# IAR project Locator_L051T8.ewp, settings and files
configuration Locator_L051T8 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L051T8 ST STM32L051T8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L051xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Tracker0831_Austria.hex
  ILINK.IlinkOutputFile: Locator_L051T8.out
  ILINK.IlinkIcfFile: stm32l051xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration HK_L051T8 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L051xx; HK_NB
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: LSD4BT0044-17D0_ObjectCode_HK_Rev01.hex
  group (top)
    ../Src/: crc16.c FOTA.c
    ../Inc/: crc16.h FOTA.h
  group Application/EWARM
    ./: startup_stm32l051xx.s
  group Application/User
    ../Src/: adc.c dma.c flash.c gpio.c gps.c i2c.c lis3dh.c lsd_mems.c main.c nb.c printf-stdarg.c rtc.c schedule.c stm32l0xx_hal_msp.c stm32l0xx_it.c tim.c tools.c UNIX.c usart.c User_ClockDriver.c
    ../Inc/: flash.h i2c.h lis3dh.h lsd_mems.h printf-stdarg.h UNIX.h
    $EW_DIR$/arm/inc/c/: intrinsics.h
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
